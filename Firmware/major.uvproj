# Keil uVision project major.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: major +hex
  c flags: Optimize=8 SizeSpeed=1
  group Main
    ./: STARTUP.A51 main.c LCD1602B.c DS1302.c dht111.c
